IMAGE_FSTYPES:append = " wic.vmdk"

IMAGE_INSTALL:append = " iptables vpngateway"
